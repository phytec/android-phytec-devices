## imx8m/phyboard_pollux/android_addition_defconfig
```kconfig
CONFIG_LIBNVDIMM=y
CONFIG_OF_PMEM=y

CONFIG_CFI_CLANG=y
CONFIG_LTO_CLANG=y
CONFIG_SHADOW_CALL_STACK=y
CONFIG_CFI_PERMISSIVE=y
```
